# Keil uVision project bootloader.uvprojx, settings and files
target devkit (ARM-ADS)
  device: STM32L053C8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: bootloader
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\bootloader\inc;.\bootloader\conf;.\support\HAL\Inc;.\common\inc
  memory RVCT4: ROM 0x8000000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x2000
  group conf
    ./app/conf/: stm32l0xx_hal_conf.h
  group src
    ./bootloader/src/: main.c system_interrupts.c app_header.c launch.s
  group inc
    ./bootloader/inc/: hwctrl.h system_interrupts.h
    ./common/inc/: app_header.h
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
